CORE_IMAGE_BASE_INSTALL += "adwaita-icon-theme \
                            adwaita-icon-theme-symbolic \
                            adwaita-icon-theme-cursors"
